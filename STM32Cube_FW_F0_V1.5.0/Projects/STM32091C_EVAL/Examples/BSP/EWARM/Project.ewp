# IAR project Project.ewp, settings and files
configuration STM32091C_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091VC ST STM32F091VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F091xC; USE_HAL_DRIVER; USE_STM32091C_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32091C_EVAL; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\Log; ..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32091C_EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f091xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../../../Drivers/BSP/Components/stlm75/: stlm75.c
  group Drivers/BSP/STM32091C_EVAL
    ../../../../../Drivers/BSP/STM32091C_EVAL/: stm32091c_eval.c stm32091c_eval_cec.c stm32091c_eval_eeprom.c stm32091c_eval_lcd.c stm32091c_eval_sd.c stm32091c_eval_tsensor.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cec.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c
  group Example/EWARM
    ./: startup_stm32f091xc.s
  group Example/User
    ../Src/: eeprom.c hdmi_cec.c joystick.c lcd.c log.c main.c sd.c stm32f0xx_it.c temperature_sensor.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
