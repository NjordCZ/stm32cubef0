# Keil uVision project Project.uvprojx, settings and files
target STM32091C-EVAL_Demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F091VC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32091C-EVAL_Demo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xC,USE_STM32091C_EVAL
  c misc: --C99
  c include: ..\Modules\main_app;..\Modules\8uart;..\Modules\thermometer;..\Modules\imagebrowser;..\Modules\filebrowser;..\Modules\lowpower;..\Demo\Inc;..\Core\Inc;..\Config;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM32091C_EVAL;..\..\..\..\Drivers\BSP\Components;..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Demo/Modules/ImageViewer
    ../Modules/imagebrowser/: imagesbrowser_app.c
  group Drivers/BSP/Component
    ../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../../Drivers/BSP/Components/stlm75/: stlm75.c
    ../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
  group Drivers/STM32F0xx_HAL_Drivers
    ../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_wwdg.c stm32f0xx_hal_usart.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_dma.c stm32f0xx_hal_uart.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_comp.c stm32f0xx_hal_crc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_irda.c stm32f0xx_hal_msp_template.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal.c stm32f0xx_hal_tsc.c stm32f0xx_hal_pcd.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_cortex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_adc.c stm32f0xx_hal_cec.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_i2s.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_rcc.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Demo/Core
    ../Core/Src/: k_demo.c k_tools.c k_menu.c k_window.c k_storage.c k_module.c
  group Demo/Modules/lowpower
    ../Modules/lowpower/: lowpower_app.c
  group Demo/Modules/thermometer
    ../Modules/thermometer/: thermometer_app.c
  group Demo/Modules/8uart
    ../Modules/8uart/: 8uart_app.c
  group Drivers/CMSIS
    ../Demo/Src/: system_stm32f0xx.c
  group Application/MDK-ARM
    ./: startup_stm32f091xc.s
  group Drivers/BSP/STM3209IC_EVAL
    ../../../../Drivers/BSP/STM32091C_EVAL/: stm32091c_eval_sd.c stm32091c_eval_tsensor.c stm32091c_eval_eeprom.c stm32091c_eval.c stm32091c_eval_lcd.c stm32091c_eval_cec.c
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Application/User
    ../Demo/Src/: stm32f0xx_it.c main.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group Demo/Modules/FileBrowser
    ../Modules/filebrowser/: filesbrowser_app.c
  group Demo/Modules/Main_App
    ../Modules/main_app/: main_app.c
software components: CMSIS:CORE 4.1.0
